# Repository can-ayaz/Arduino-ATmega2560-Gelistirme-karti-yapimi

File README.md:

# Arduino-ATmega2560-Gelistirme-karti-yapimi
**Arduino AT(mega 2560) Geliştirme Kartı Yapımı**

Merhaba arkadaşlar  bu yazımda ATMEL firmasının tasarlamış ve üretmiş olduğu Atmega2560  Mikrodenetleyicisine uygun bir geliştirme kartı tasarlayacağız .Elimde bulunduğu için ve Arduino mega'mı kaybettiğim için (bahsi geçen mikrodenetleyiciyi kullanıyor) kendi Arduino mega geliştirme kartımı tasarlayıp birlikte üreteceğiz.

**Daha fazlası içi ziyaret edebilirsiniz: https://canayazblog.wordpress.com/**

## EAGLE design canayaz2560mega/canayaz2560mega.brd

Parts:
5V: M06; 06P
C1: 10nF; 1206
C2, C5: 100nF; 1206
C3: 10uF; 1206
C4: 1uF; 1206
C10, C11: 18pF; 1206
C13, C14: 22pF; CAPC3216X178N
CRYSTAL: 12MHZ; CSM-7X-DU
CRYSTAL3: 16Mhz; CSM-7X-DU
GND: M06; 06P
IC3: ATMEGA2560-16AU; TQFP100
LED_GREEN: LED1206; 1206
LED_RX: YELLOW; LED1206
LED_TX: YELLOW; LED1206
LED_YELLOW: LED1206; 1206
R1: 10K; R1206
R2, R3: 499; 1206
R6, R7: 2K7; R1206
R8, R9: 1K; R1206
RST: M01PTH_LONGPAD; 1X01_LONGPAD
SL1, SL4: M04; 04P
SL2: M16; 16P
SL3: M09; 09P
SL5: M10; 10P
U2: CH340G; SO016
U$7: USB-MINIB-5PIN; USB-MINIB
X1: C-GRID-23-70543; 70543-23
X2: C-GRID-20-70543; 70543-20

Connections:
1: IC3.1 ((OC0B)PG5), SL3.1
4: IC3.4 ((XCK0/AIN0)PE2), SL3.4
5: IC3.5 ((OC3A/AIN1)PE3), SL3.5
5V: 5V.1, 5V.2, 5V.3, 5V.4, 5V.5, 5V.6, C3.1, C4.1, C5.1, IC3.10 (VCC), IC3.31 (VCC1), IC3.61 (VCC2), IC3.80 (VCC3), IC3.98 (AREF), IC3.100 (AVCC), LED_GREEN.1 (A), R1.2, R6.2, R7.2, U2.16 (VCC), U$7.VBUS
6: IC3.6 ((OC3B/INT4)PE4), SL3.6
7: IC3.7 ((OC3C/INT5)PE5), SL3.7
8: IC3.8 ((T3/INT6)PE6), SL3.8
9: IC3.9 ((CLKO/ICP3/INT7)PE7), SL3.9
12: IC3.12 (PH0(RXD2)), SL4.1
13: IC3.13 (PH1(TXD2)), SL4.2
14: IC3.14 (PH2(XCK2)), SL4.3
15: IC3.15 (PH3(OC4A)), SL4.4
16: IC3.16 (PH4(OC4B)), SL5.1
17: IC3.17 (PH5(OC4C)), SL5.2
18: IC3.18 (PH6(OC2B)), SL5.3
19: IC3.19 ((SS/PCINT0)PB0), SL5.4
20: IC3.20 ((SCK/PCINT1)PB1), SL5.5
21: IC3.21 ((MOSI/PCINT2)PB2), SL5.6
22: IC3.22 ((MISO/PCINT3)PB3), SL5.7
23: IC3.23 ((OC2A/PCINT4)PB4), SL5.8
24: IC3.24 ((OC1A/PCINT5)PB5), SL5.9
25: IC3.25 ((OC1B/PCINT6)PB6), SL5.10
26: IC3.26 ((OC0A/OC1C/PCINT7)PB7), LED_YELLOW.1 (A), SL1.1
27: IC3.27 (PH7(T4)), SL1.2
28: IC3.28 ((TOSC2)PG3), SL1.3
29: IC3.29 ((TOSC1)PG4), SL1.4
35: IC3.35 (PL0(ICP4)), SL2.16
36: IC3.36 (PL1(ICP5)), SL2.15
37: IC3.37 (PL2(T5)), SL2.14
38: IC3.38 (PL3(OC5A)), SL2.13
39: IC3.39 (PL4(OC5B)), SL2.12
40: IC3.40 (PL5(OC5C)), SL2.11
41: IC3.41 (PL6), SL2.10
42: IC3.42 (PL7), SL2.9
43: IC3.43 ((SCL/INT0)PD0), SL2.8
44: IC3.44 ((SDA/INT1)PD1), SL2.7
45: IC3.45 ((RXD1/INT2)PD2), SL2.6
46: IC3.46 ((TXD1/INT3)PD3), SL2.5
47: IC3.47 ((ICP1)PD4), SL2.4
48: IC3.48 ((XCK1)PD5), SL2.3
49: IC3.49 ((T1)PD6), SL2.2
50: IC3.50 ((T0)PD7), SL2.1
51: IC3.51 ((WR)PG0), X1.23
52: IC3.52 ((RD)PG1), X1.22
53: IC3.53 ((A8)PC0), X1.21
54: IC3.54 ((A9)PC1), X1.20
55: IC3.55 ((A10)PC2), X1.19
56: IC3.56 ((A11)PC3), X1.18
57: IC3.57 ((A12)PC4), X1.17
58: IC3.58 ((A13)PC5), X1.16
59: IC3.59 ((A14)PC6), X1.15
60: IC3.60 ((A15)PC7), X1.14
63: IC3.63 (PJ0(RXD3/PCINT9)), X1.13
64: IC3.64 (PJ1(TXD3/PCINT10)), X1.12
65: IC3.65 (PJ2(XCK3/PCINT11)), X1.11
66: IC3.66 (PJ3(PCINT12)), X1.10
67: IC3.67 (PJ4(PCINT13)), X1.9
68: IC3.68 (PJ5(PCINT14)), X1.8
69: IC3.69 (PJ6(PCINT15)), X1.7
70: IC3.70 ((ALE)PG2), X1.6
71: IC3.71 ((AD7)PA7), X1.5
72: IC3.72 ((AD6)PA6), X1.4
73: IC3.73 ((AD5)PA5), X1.3
74: IC3.74 ((AD4)PA4), X1.2
75: IC3.75 ((AD3)PA3), X1.1
76: IC3.76 ((AD2)PA2), X2.20
77: IC3.77 ((AD1)PA1), X2.19
78: IC3.78 ((AD0)PA0), X2.18
79: IC3.79 (PJ7), X2.17
82: IC3.82 (PK7(ADC15/PCINT23)), X2.16
83: IC3.83 (PK6(ADC14/PCINT22)), X2.15
84: IC3.84 (PK5(ADC13/PCINT21)), X2.14
85: IC3.85 (PK4(ADC12/PCINT20)), X2.13
86: IC3.86 (PK3(ADC11/PCINT19)), X2.12
87: IC3.87 (PK2(ADC10/PCINT18)), X2.11
88: IC3.88 (PK1(ADC9/PCINT17)), X2.10
89: IC3.89 (PK0(ADC8/PCINT16)), X2.9
90: IC3.90 ((ADC7/TDI)PF7), X2.8
91: IC3.91 ((ADC6/TDO)PF6), X2.7
92: IC3.92 ((ADC5/TMS)PF5), X2.6
93: IC3.93 ((ADC4/TCK)PF4), X2.5
94: IC3.94 ((ADC3)PF3), X2.4
95: IC3.95 ((ADC2)PF2), X2.3
96: IC3.96 ((ADC1)PF1), X2.2
97: IC3.97 ((ADC0)PF0), X2.1
GND: C1.2, C3.2, C4.2, C5.2, C10.2, C11.2, C13.1 (C1), C14.1 (C1), GND.1, GND.2, GND.3, GND.4, GND.5, GND.6, IC3.11 (GND), IC3.32 (GND1), IC3.62 (GND2), IC3.81 (GND3), IC3.99 (AGND), R2.2, R3.2, U2.1 (GND), U$7.GND
unnamed: U2.5 (UD+), U$7.D+
unnamed: LED_RX.1 (A), R6.1
unnamed: U2.6 (UD-), U$7.D-
unnamed: C14.2 (C2), CRYSTAL3.1, IC3.34 (XTAL1)
unnamed: C13.2 (C2), CRYSTAL3.2, IC3.33 (XTAL2)
unnamed: LED_YELLOW.2 (C), R3.1
unnamed: LED_TX.1 (A), R7.1
unnamed: LED_GREEN.2 (C), R2.1
OSC_IN: C10.1, CRYSTAL.2, U2.8 (XO)
OSC_OUT: C11.1, CRYSTAL.1, U2.7 (XI)
RST: C2.2, IC3.30 (RESET), R1.1, RST.1
RST-FTDI: C2.1, U2.13 (!DTR)
RX-340: IC3.3 ((TXD0)PE1), R9.2, SL3.2
RXD: LED_RX.2 (C), R9.1, U2.3 (RXD)
TX-340: IC3.2 ((RXD0/PCIN8)PE0), R8.2, SL3.3
TXD: LED_TX.2 (C), R8.1, U2.2 (TXD)
V3: C1.1, U2.4 (V3)

Board: 2 copper layers, 98.0 x 73.0 mm, 35 parts (0 on the bottom side), 103 nets.

Notices in the files:
parts and their libraries:
01_SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-DigitalIC: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
